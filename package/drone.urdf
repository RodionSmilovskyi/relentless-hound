Commit message: Drone env refactoring

File: package/drone.urdf (robot description, URDF)
Before this commit: robot simple_quadcopter, 5 links, 4 joints
Links:
- link base_link: geometry collision box size=1 1 1.5; visual mesh filename=package://drone.stl scale=1 1 1
